options:
  parameters:
    description: Correlacao com atraso 16 em amostras Wi-Fi
    generate_options: qt_gui
    id: week1_frame_detection
    output_language: python
    title: Week 1 - Correlacao normalizada
  states: {}

blocks:
- name: nwin
  id: variable
  parameters:
    comment: Comparar 16, 48 e 96 amostras
    value: '48'
  states: {}
- name: playback_rate
  id: variable
  parameters:
    comment: Amostras por segundo reproduzidas no computador
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Taxa fisica para o eixo temporal
    value: 20e6
  states: {}
- name: avoid_zero
  id: blocks_add_const_vxx
  parameters:
    comment: Evita divisao por zero no arranque.
    const: '1e-8'
    type: float
  states: {}
- name: conjugate
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: delay_16
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    comment: Excerto do Sample1, repetido; offset e length em amostras complexas
    file: recordings/Sample1_20MHz_Channel36.bin
    length: '900'
    offset: '1247600'
    repeat: 'True'
    type: complex
  states: {}
- name: instant_power
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: magnitude
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: multiply
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: normalize
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: playback
  id: blocks_throttle2
  parameters:
    samples_per_second: playback_rate
    type: complex
  states: {}
- name: sum_correlation
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1.0] * nwin'
    type: ccf
  states: {}
- name: sum_power
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1.0] * nwin'
    type: fff
  states: {}
- name: time_plot
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    label1: Correlacao
    name: '"Detecao de trama (gravacao Wi-Fi)"'
    size: '768'
    srate: samp_rate
    tr_delay: '3e-6'
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Autocorrelacao normalizada
    ymax: '1.5'
    ymin: '-0.1'
  states: {}

connections:
- [avoid_zero, '0', normalize, '1']
- [conjugate, '0', multiply, '1']
- [delay_16, '0', conjugate, '0']
- [file_source, '0', playback, '0']
- [instant_power, '0', sum_power, '0']
- [magnitude, '0', normalize, '0']
- [multiply, '0', sum_correlation, '0']
- [normalize, '0', time_plot, '0']
- [playback, '0', delay_16, '0']
- [playback, '0', instant_power, '0']
- [playback, '0', multiply, '0']
- [sum_correlation, '0', magnitude, '0']
- [sum_power, '0', avoid_zero, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
